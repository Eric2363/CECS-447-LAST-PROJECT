# Keil uVision project Project.uvprojx, settings and files
target Project (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../src/: main.c startup.s ModuleTest.c
    ../src/drivers/: ButtonLED.c ButtonLED.h wtimer.c wtimer.h PLL.c PLL.h UART.c UART.h Latch.c Latch.h I2C.c I2C.h MPU6050.c MPU6050.h
software components: CMSIS:CORE 5.6.0
